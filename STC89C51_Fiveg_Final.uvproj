# Keil uVision project STC89C51_Fiveg_Final.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: STC89C51_Fiveg_Final +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\Source\ds18b20;.\Source\keyValue;.\Source\smg
  group Test
    ./Test/: main.c
  group Source
    ./Source/smg/: smg.c
    ./Source/ds18b20/: ds18b20.c
    ./Source/keyValue/: keyValue.c
  group Public
    ./Public/: public.c
